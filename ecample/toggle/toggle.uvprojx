# Keil uVision project toggle.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: toggle
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c
  group ::CMSIS
    d:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
  group ::Device
    RTE/Device/MKL46Z128xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
