# Keil uVision project blink.uvprojx, settings and files
target blinky (ARM-ADS)
  device: MKL46Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blink
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./: main.c
  group ::Device
    RTE/Device/MKL46Z128xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
